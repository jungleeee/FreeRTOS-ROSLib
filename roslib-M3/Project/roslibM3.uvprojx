# Keil uVision project roslibM3.uvprojx, settings and files
target roslibM3 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: roslibM3 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Code\App;..\Code\App\ros;..\Code\App\ros\inc;..\Code\App\ros\src;..\Code\Bsp\inc;..\Code\Bsp\src;..\Code\Hal\inc;..\Code\Hal\src;..\Code\FreeRTOS\Demo\CORTEX_STM32F103_Keil;..\Code\FreeRTOS\Source;..\Code\FreeRTOS\Source\include;..\Code\FreeRTOS\Source\portable\MemMang;..\Code\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\src;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Project;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\Utilities;..\Code\STM32F10x_StdPeriph_Lib_V3.5.0\_htmresc;..\Code\ROS_LIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Ros
    ../Code/App/: main.c
    ../Code/App/ros/src/: ros_bsp.c ros_test.cpp
  group Hal
    ../Code/Hal/src/: serial.c
  group Bsp
    ../Code/Bsp/src/: usart.c
  group FreeRTOS
    ../Code/FreeRTOS/Source/: tasks.c queue.c list.c
    ../Code/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Code/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Code/FreeRTOS/Demo/CORTEX_STM32F103_Keil/: FreeRTOSConfig.h
  group F10x_StdPeriph_Lib_V3.5.0
    ../Code/STM32F10x_StdPeriph_Lib_V3.5.0/Project/: stm32f10x_it.c stm32f10x_conf.h
    ../Code/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h
    ../Code/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../Code/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group ROS_LIB
    ../Code/ROS_LIB/: duration.cpp time.cpp ros.h stm32Hardware.h
